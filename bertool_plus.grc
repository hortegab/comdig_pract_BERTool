options:
  parameters:
    author: Homero Ortega Boada
    category: Custom
    description: Dale un valor a Es/No, corre el flujograma y obten la SER. Puedes sacar tantos valores como para construir una curva de SER
    generate_options: qt_gui
    id: ser_simulation
    output_language: python
    run: run_stop
    title: SER Simulation
  states: {}

blocks:
- name: Bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: EsN0max
  id: variable
  parameters:
    value: '20.'
  states: {}
- name: EsN0min
  id: variable
  parameters:
    value: '0.'
  states: {}
- name: M
  id: variable
  parameters:
    value: len(MiconstellationObject.points())
  states: {}
- name: MaxCount
  id: variable
  parameters:
    value: int(1e7)
  states: {}
- name: MaxErrors
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: MiconstellationObject
  id: variable_constellation
  parameters:
    const_points: digital.constellation_qpsk().points()
    dims: '1'
    precision: '8'
    rot_sym: '4'
    sym_map: (0,1,2,3)
    type: calcdist
  states: {}
- name: N_snr
  id: variable
  parameters:
    value: '128'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Rs*Bps
  states: {}
- name: Rs
  id: variable
  parameters:
    value: samp_rate/Sps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: const
  id: variable
  parameters:
    value: digital.constellation_bpsk().points()
  states: {state: disabled}
- name: const
  id: variable
  parameters:
    value: digital.qam_constellation(16).points()
  states: {state: disabled}
- name: const
  id: variable
  parameters:
    value: digital.constellation_qpsk().points()
  states: {state: disabled}
- name: run_stop
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,0,1,1
    label: Inicial/Parar
    'true': 'True'
    type: int
    value: 'True'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: analog_random_source_x
  id: analog_random_source_x
  parameters:
    max: M
    min: '0'
    num_samps: '10000000'
    repeat: 'True'
    type: byte
  states: {}
- name: b_BERTool_Channel_0
  id: b_BERTool_Channel
  parameters:
    EsN0max: EsN0max
    EsN0min: EsN0min
    N_snr: N_snr
    Rs: Rs
    tipo_mod: '"SER QPSK"'
  states: {}
- name: digital_chunks_to_symbols_xx
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: MiconstellationObject.points()
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: MiconstellationObject
  states: {}
- name: import
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    note: Modulación BPSK
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Modulación 16QAM
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: Modulación 4PSK
  states: {}

connections:
- [analog_random_source_x, '0', b_BERTool_Channel_0, '1']
- [analog_random_source_x, '0', digital_chunks_to_symbols_xx, '0']
- [b_BERTool_Channel_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_chunks_to_symbols_xx, '0', b_BERTool_Channel_0, '0']
- [digital_constellation_decoder_cb_0, '0', b_BERTool_Channel_0, '2']

metadata:
  file_format: 1
